* C:\Users\mamat\eSim-Workspace\CD4048BMS_IC\CD4048BMS_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/03/25 12:11:02

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U13-Pad1_ Net-_U10-Pad2_ Net-_U9-Pad16_ Net-_U9-Pad15_ Net-_U9-Pad14_ Net-_U9-Pad13_ Net-_U11-Pad2_ GND Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U9-Pad12_ Net-_U9-Pad11_ Net-_U9-Pad10_ Net-_U9-Pad9_ Net-_U11-Pad2_ Net-_X1-Pad16_ CD4048BMS
X2  Out Net-_U10-Pad2_ Net-_U14-Pad16_ Net-_U14-Pad15_ Net-_U14-Pad14_ Net-_U14-Pad13_ Net-_U11-Pad2_ GND Net-_U11-Pad2_ Net-_U11-Pad2_ Net-_U14-Pad12_ Net-_U14-Pad11_ Net-_U14-Pad10_ Net-_U14-Pad9_ Net-_U13-Pad2_ Net-_X2-Pad16_ CD4048BMS
v11  Net-_X2-Pad16_ GND 5
v10  Net-_X1-Pad16_ GND 5
v2  A1 GND pulse
v3  B1 GND pulse
v1  C1 GND pulse
v4  D1 GND pulse
v5  E1 GND pulse
v6  F1 GND pulse
v7  G1 GND pulse
v8  H1 GND pulse
U9  A1 B1 C1 D1 E1 F1 G1 H1 Net-_U9-Pad9_ Net-_U9-Pad10_ Net-_U9-Pad11_ Net-_U9-Pad12_ Net-_U9-Pad13_ Net-_U9-Pad14_ Net-_U9-Pad15_ Net-_U9-Pad16_ adc_bridge_8
v16  A2 GND pulse
v17  B2 GND pulse
v19  C2 GND pulse
v18  D2 GND pulse
v12  E2 GND pulse
v13  F2 GND pulse
v14  G2 GND pulse
v15  H2 GND pulse
U14  A2 B2 C2 D2 E2 F2 G2 H2 Net-_U14-Pad9_ Net-_U14-Pad10_ Net-_U14-Pad11_ Net-_U14-Pad12_ Net-_U14-Pad13_ Net-_U14-Pad14_ Net-_U14-Pad15_ Net-_U14-Pad16_ adc_bridge_8
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ adc_bridge_1
v9  Net-_U10-Pad1_ GND 5
U11  GND Net-_U11-Pad2_ adc_bridge_1
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ adc_bridge_1
U1  A1 plot_v1
U2  B1 plot_v1
U3  C1 plot_v1
U4  D1 plot_v1
U5  E1 plot_v1
U6  F1 plot_v1
U7  G1 plot_v1
U8  H1 plot_v1
U18  A2 plot_v1
U19  B2 plot_v1
U20  C2 plot_v1
U22  D2 plot_v1
U21  E2 plot_v1
U17  F2 plot_v1
U15  G2 plot_v1
U16  H2 plot_v1
U12  Out plot_v1

.end
